// 1017 - 装箱问题 (带2个边界bug)
// 测试模式信号（宏开启时提交）：
//   WA = 用例通过（未触发bug），程序正常结束，输出结果（与OJ数据不符）
//   RE = 用例触发bug，断言失败，程序崩溃
// 本地测试：取消注释 #define CASE 1（或2），修改对应分支的测试数据，运行即可。

#define CASE 7 // 默认关闭，测试时取消注释

#include <iostream>
#include <string>
#include <sstream>
#include <cassert>
using namespace std;

template <typename T>
void my_assert(bool condition, const string &expr_str, int line_num, const T &msg)
{
    if (!condition)
    {
        // 触发崩溃（和原assert(false)效果一致）
        cerr << msg << " | 表达式：" << expr_str << " | 行号：" << line_num << endl;
        abort(); // 也可以用 assert(false)，效果相同
    }
}

int main()
{
#ifdef CASE
    // ========== 测试模式：准备硬编码输入与预期输出 ==========
    string test_input, expected_output;
#if CASE == 1
    // 请在此处填入你的测试用例（输入）和预期输出
    test_input = "0 0 4 0 0 1\n7 5 1 0 0 0\n0 0 0 0 0 0\n";
    expected_output = "2\n1\n";
#elif CASE == 2
    // 预留其他用例集（用户可自行添加）
    test_input = "11 0 0 0 1 0\n0 0 0 0 0 0\n";
    expected_output = "1\n";
#elif CASE == 3
    // 预留其他用例集（用户可自行添加）
    test_input = "0 0 0 0 0 1\n0 0 0 0 1 0\n0 0 0 1 0 0\n0 0 1 0 0 0\n0 1 0 0 0 0\n1 0 0 0 0 0\n0 0 0 0 0 0\n";
    expected_output = "1\n1\n1\n1\n1\n1\n";
#elif CASE == 4
    // 预留其他用例集（用户可自行添加）
    test_input = "0 0 0 0 0 100\n55 0 0 0 5 0\n56 0 0 0 5 0\n0 5 0 1 0 0\n0 6 0 1 0 0\n0 0 0 0 0 0\n";
    expected_output = "100\n5\n6\n1\n2\n";
#elif CASE == 5
    // 预留其他用例集（用户可自行添加）
    test_input = "0 0 1 0 0 0\n0 0 2 0 0 0\n0 0 3 0 0 0\n0 0 4 0 0 0\n0 0 5 0 0 0\n0 0 6 0 0 0\n0 0 7 0 0 0\n0 0 8 0 0 0\n0 0 9 0 0 0\n0 0 0 0 0 0\n";
    expected_output = "1\n1\n1\n1\n2\n2\n2\n2\n3\n";
#elif CASE == 6
    // 预留其他用例集（用户可自行添加）
    test_input = "0 5 1 0 0 0\n0 6 1 0 0 0\n0 5 3 0 0 0\n0 10 3 0 0 0\n0 11 3 0 0 0\n0 0 0 0 0 0\n";
    expected_output = "1\n2\n2\n2\n3\n";
#elif CASE == 7
    // 预留其他用例集（用户可自行添加）
    test_input = "27 0 1 0 0 0\n28 0 1 0 0 0\n18 0 2 0 0 0\n19 0 2 0 0 0\n0 0 0 0 0 0\n";
    expected_output = "1\n2\n1\n2\n";
#elif CASE == 8
    // 预留其他用例集（用户可自行添加）
    test_input = "1 1 1 1 1 1\n0 0 0 0 0 0\n";
    expected_output = "4\n";
#elif CASE == 9
    // 预留其他用例集（用户可自行添加）
    test_input = "100 100 100 100 100 100\n0 0 0 0 0 0\n";
    expected_output = "325\n";
#else
#error "Unsupported CASE value"
#endif
    // 重定向输入流
    istringstream iss(test_input);
    cin.rdbuf(iss.rdbuf());

    // 重定向输出流到字符串流，以便捕获结果
    ostringstream oss;
    streambuf *old_cout = cout.rdbuf(oss.rdbuf());
#endif

    // ========== 核心逻辑（含2个边界bug） ==========
    int a1, a2, a3, a4, a5, a6;
    while (cin >> a1 >> a2 >> a3 >> a4 >> a5 >> a6)
    {
        if (a1 == 0 && a2 == 0 && a3 == 0 && a4 == 0 && a5 == 0 && a6 == 0)
            break;

        int count = 0;
        // 6*6 每个单独占一个包裹
        count += a6;

        // 5*5 每个占一个包裹，剩余空间可放1*1
        count += a5;
        // bug1: 5*5剩余1*1位置由11改为10（少算1个位置）
        a1 = max(0, a1 - a5 * 10); // 正确应为 a5 * 11
        // a1 = max(0, a1 - a5 * 11);

        // 4*4 每个占一个包裹，剩余空间可放2*2和1*1
        count += a4;
        int space2_for_4 = a4 * 5;
        if (a2 <= space2_for_4)
        {
            int space1_left = (space2_for_4 - a2) * 4;
            a1 = max(0, a1 - space1_left);
            a2 = 0;
        }
        else
        {
            a2 -= space2_for_4;
        }

        // 3*3 每4个可放一个包裹
        count += (a3 + 3) / 4;
        int remainder3 = a3 % 4;
        if (remainder3 > 0)
        {
            int space2_for_3 = 0;
            int space1_for_3 = 0;
            if (remainder3 == 1)
            {
                // bug2: 3*3剩余1个时，可放2*2数量由5改为4（少放1个2*2）
                space2_for_3 = 4; // 正确应为5
                // space2_for_3 = 5;
                space1_for_3 = 7;
            }
            else if (remainder3 == 2)
            {
                space2_for_3 = 3;
                space1_for_3 = 6;
            }
            else if (remainder3 == 3)
            {
                space2_for_3 = 1;
                space1_for_3 = 5;
            }
            int used2 = min(a2, space2_for_3);
            a2 -= used2;
            int space1_left = space1_for_3 + (space2_for_3 - used2) * 4;
            a1 = max(0, a1 - space1_left);
        }

        // 处理剩余的2*2
        if (a2 > 0)
        {
            count += (a2 + 8) / 9;
            int used2_last = a2 % 9;
            if (used2_last > 0)
            {
                int space1_last = (9 - used2_last) * 4;
                a1 = max(0, a1 - space1_last);
            }
        }

        // 处理剩余的1*1
        if (a1 > 0)
        {
            count += (a1 + 35) / 36;
        }

        cout << count << endl;
    }

#ifdef CASE
    // ========== 测试模式：捕获输出、断言、恢复并输出结果 ==========
    string result = oss.str();
    cout.rdbuf(old_cout);

    // 单次断言：失败则触发RE，成功则继续
    my_assert(
        result == expected_output,                                 // 1. condition：断言判断条件（bool）
        "result == expected_output",                               // 2. expr_str：条件的字符串形式（方便打印）
        __LINE__,                                                  // 3. line_num：当前行号（用__LINE__自动取，不用手动写数字）
        "实际输出:\n" + result + "\n预期输出:\n" + expected_output // 4. msg：自定义提示
    );

    // 断言通过后输出结果（OJ判WA）
    cout << result;
#endif

    return 0;
}